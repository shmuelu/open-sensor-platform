# Keil uVision project osp-steval.uvproj, settings and files
target OSP-Reference (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OspSensorHub
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ANDROID_DEMO,HSE_VALUE=16000000,USE_STDPERIPH_DRIVER,STM32F10X_HD,DEBUG_BUILD,DEBUG_OUTPUT,STEVAL_MKI109V2,UART_DMA_ENABLE,ASF_PROFILING,ON_DEMAND_PROFILING
  c include: ..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\alg;..\sources\app;..\sources\config;..\sources\boardsupport;..\..\..\common\modules\sensor-drivers;..\..\..\common\modules\bus-drivers;..\..\..\..\external\mcu\stm32f1-cm3\cslib;..\..\..\..\external\mcu\stm32f1-cm3\cslib\inc;..\..\..\..\external\rtos\rtx\inc;..\..\..\..\external\mcu\cmsis\device\st\stm32f10x\include;..\..\..\..\external\rtos\rtx\cm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../../../../external/MCU/STM32F1-CM3/: startup_stm32f10x_hd.s
  group CSLib
    ../../../../external/MCU/STM32F1-CM3/CSLib/Src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group Retarget
    ../../../../external/MCU/STM32F1-CM3/Retarget/: Retarget.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../sources/config/: rtx_conf_cm.c
    ../../../../external/RTOS/RTX/lib/: RTX_CM3.lib
  group Alg
    ../../../common/alg/: osp_embeddedalgcalls.c stepdetector.c stepsegmenter.c signalgenerator.c significantmotiondetector.c
  group App-Common
    ../../../common/app/: algorithm_t.c cmdhandler_t.c debugprint.c instrmgr_t.c instrmgr_user.c osp-api.c sensoracq_t.c
  group App
    ../sources/app/: console_util.c i2c_slavecomm_t.c main.c taskinit_user.c HostFunctions.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c stm32f10x_it.c system_stm32f10x.c
  group Bus-Drivers
    ../../../common/modules/bus-drivers/stm32f1-cm3/: i2c_driver.c
  group Sensor-Drivers
    ../../../common/modules/sensor-drivers/: acc_lsm303dlhc_i2c.c gyro_l3gd20_i2c.c mag_lsm303dlhc_i2c.c
